# Keil uVision project F407_Source.uvprojx, settings and files
target F407_Source (::::)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_Source +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx, USE_HAL_DRIVER
  c include: User\Include;Platform\STM32F4xx_HAL_Driver\Inc;Platform\STM32F4xx_HAL_Driver\Inc\Legacy;Platform\CMSIS\Device\ST\STM32F4xx\Include;Platform\CMSIS\Core\Include;.\APP\Communication\Include;.\BSP\Include;.\Middlewares\FATFS\Include;.\Middlewares\FATFS\FATFS_app;.\Middlewares\WIZnet\Include;.\Middlewares\WIZnet\WIZnet_app
  asm define: STM32F407xx, USE_HAL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Communication
    ./APP/Communication/Source/: fds_data.c fds_param.c fds_handler.c fds_protocol.c
  group BSP
    ./BSP/Source/: bsp_adc.c bsp_gpio.c bsp_iic.c bsp_spi.c bsp_sram.c bsp_tim.c bsp_usart.c bsp_sdio_sd.c
  group User
    ./User/Source/: Main.c stm32f4xx_it.c scheduler.c ExtHardwareTest.c
    ./User/Include/: stm32f4xx_hal_conf.h
    ./Platform/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ./Platform/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FATFS
    ./Middlewares/FATFS/Source/: diskio.c exfuns.c fattester.c ff.c ffsystem.c ffunicode.c
  group Middlewares/FATFS/FATFS_app
    ./Middlewares/FATFS/FATFS_app/: SD.c
  group Middlewares/WIZnet
    ./Middlewares/WIZnet/Source/: w6100.c wiz_loopback.c wiz_socket.c wizchip_conf.c
  group Middlewares/WIZnet/WIZnet_app
    ./Middlewares/WIZnet/WIZnet_app/: spi_w6100.c ETH_WIZdemo.c WIZnet_TcpClient.c WIZnet_TcpSever.c WIZnet_UDP.c
  group Startup
    ./Platform/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
